# Keil uVision project stm32_high.uvproj, settings and files
target gpi-8310 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gpi-8310 +hex
  AfterMake: "F:\__Cloud\Dropbox\___prj\Ce-08-03.GPI-8310(GATEWAY)\main\clean\prj\iap_merge-lte-212.bat"
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin "#L" -o "$P\..\obj\gpi-8310-main.bin"
  c flags: Optim=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\CMSIS\Include;..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32_USB-FS-Device_Driver\inc;..\lib\STM32_USB-FS-Device_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src;..\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x80000
  memory RVCT6: RAM 0x60000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../driver/: adc.c buzzer.c i2c_ee.c key.c lcd70.c lcd.c led.c timer.c usart.c sflash.c
    ../app/: agent_date_change.c agent_discharge_calc.c agent_discharge_stop.c agent_discharge_input.c agent_cdma_task.c agent_make_baichul_packet.c agent_baichul_send.c agent_weight_display.c agent_discharge_stop_delay.c agent_minute_event.c agent_minute_event.h
    ../bsp/: board_gpi8510.h
    ../src/: CAL.C font.c hw_config.c icon.c main.c rtc.c SET.C spi.c test.c var.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_systick.c
    ../service/: global.c parsing.c queue.c rs485.c sms.c tcpip_send.c zigbee.c agent_input_filter.c agent_weight.c
  group CMSIS
    ../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ../lib/STM32_USB-FS-Device_Lib_V3.4.0/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group FWLIB
    ../src/: STM32F10xR.LIB
